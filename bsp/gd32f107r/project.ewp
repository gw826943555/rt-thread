# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: Libraries\CMSIS\GD\GD32F10x\Include; ..\..\include; ..\..\components\finsh; drivers; ..\..\components\libc\compilers\dlib; .; applications; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\spi\sfud\inc; Libraries\CMSIS; ..\..\libcpu\arm\common; ..\..\components\dfs\filesystems\elmfat; Libraries\GD32F10x_standard_peripheral\Include; ..\..\components\dfs\filesystems\devfs; ..\..\components\drivers\include; ..\..\components\drivers\spi; ..\..\components\dfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: gd32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; GD32F30X_HD; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group GD32_Lib
    Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_ctc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
    Libraries/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_hd.s
    Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
